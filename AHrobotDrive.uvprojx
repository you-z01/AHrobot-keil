# Keil uVision project AHrobotDrive.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AHrobotDrive +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\FreeRTOS\include;.\Public;.\Peripheral_Driver;.\App;.\Task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group FreeRTOS_core
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_port
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Public
    ./Public/: system.c SysTick.c
  group Peripheral_Driver
    ./Peripheral_Driver/: led.c oled.c usart.c iic.c encodeMotor.c steerEngine.c stepMotor.c
  group App
    ./App/: encodingMotor.c pid.c steppingMotor.c steeringEngine.c
  group Task
    ./Task/: Bluetooth_control.c
  group User
    ./User/: main.c stm32f4xx_it.c
    ./: readme.txt
